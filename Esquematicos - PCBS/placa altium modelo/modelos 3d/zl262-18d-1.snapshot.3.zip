# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (file zl262-18d_p2-54_l23-36_w5_h8-5.prt.2)

Parameters:
  PTC_COMMON_NAME = "fem1v_p2-54_l2-54_w2-54_h8-5.prt"